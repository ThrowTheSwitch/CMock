# IAR project cmock_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7X256 Atmel AT91SAM7X256
  ICCARM.CCIncludePath2: ..\test\system\src
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: at91SAM7X256_FLASH.xcl
configuration Simulate (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SIMULATE
configuration Release (ARM)
  as the first configuration, except:
  group source
    ../test/system/src/: AdcConductor.c AdcHardware.c AdcHardwareConfigurator.c AdcModel.c AdcTemperatureSensor.c Executor.c Main.c Model.c TaskScheduler.c TemperatureCalculator.c TemperatureFilter.c TimerConductor.c TimerConfigurator.c TimerHardware.c TimerInterruptConfigurator.c TimerInterruptHandler.c TimerModel.c UsartBaudRateRegisterCalculator.c UsartConductor.c UsartConfigurator.c UsartHardware.c UsartModel.c UsartPutChar.c UsartTransmitBufferStatus.c
  group Startup
    ./: Cstartup.s79 Cstartup_SAM7.c
